# IAR project tws1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x10
  ICCSTM8.CCIncludePath2: ..\atomthreads\ports\stm8; ..\atomthreads\ports\stm8\stm8s-periphs; ..\atomthreads\kernel; ..\atomthreads\extra; ..\atomthreads\com; ..\atomthreads\drv; ..\atomthreads\lib; drivers; port
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: tws1Charger.hex
  ILINK.IlinkOutputFile: tws1Charger.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group atomthreads/com
    ../atomthreads/com/: console.h debug.h debug_port.h kassert.h syslog.h
  group atomthreads/com/console
    ../atomthreads/com/console/: console.c
  group atomthreads/com/debug
    ../atomthreads/com/debug/: debug.c
  group atomthreads/com/kassert
    ../atomthreads/com/kassert/: kassert.c
  group atomthreads/com/syslog
    ../atomthreads/com/syslog/: syslog.c
  group atomthreads/drv
    ../atomthreads/drv/: adc.h io.h iosdrv.h pin.h sio.h
  group atomthreads/drv/adc
    ../atomthreads/drv/adc/: adc.c
  group atomthreads/drv/iosdrv
    ../atomthreads/drv/iosdrv/: iosdrv.c
  group atomthreads/drv/pin
    ../atomthreads/drv/pin/: pin.c
  group atomthreads/drv/sio
    ../atomthreads/drv/sio/: sio.c
  group atomthreads/extra
    ../atomthreads/extra/: event.c event.h
  group atomthreads/kernel
    ../atomthreads/kernel/: atom.h atomkernel.c atommutex.c atommutex.h atomport-template.h atomqueue.c atomqueue.h atomsem.c atomsem.h atomtimer.c atomtimer.h
  group atomthreads/lib
    ../atomthreads/lib/: mem.h numberical.h queue.h ringbuffer.h
  group atomthreads/lib/buffer
    ../atomthreads/lib/buffer/: ringbuffer.c
  group atomthreads/lib/numberical
    ../atomthreads/lib/numberical/: numberical.c
  group atomthreads/ports/stm8s
    ../atomthreads/ports/stm8/: atomport-asm-iar.s atomport-private.h atomport.c atomport.h stm8s_conf.h
  group atomthreads/ports/stm8s-periphs
    ../atomthreads/ports/stm8/stm8s-periphs/: stm8s.h stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim1.c stm8s_uart1.c
  group Charger/app
    app/: boostmgr.c device.c eventmgr.c hallswitchmgr.c ledmgr.c mainApp.c powermgr.c watchdog.c
  group Charger/drivers
    drivers/: stm8s003adc.h stm8s003uart.h
  group Charger/drivers/adc
    drivers/adc/: stm8s003adc.c
  group Charger/drivers/uart
    drivers/uart/: stm8s003uart.c
  group Charger/port
    port/: port.c port.h
